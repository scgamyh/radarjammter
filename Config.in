## Config.in
```kconfig
config BR2_PACKAGE_RADARJAMMING
	bool "RADARJAMMING source app"
	help
	  eric RADARJAMMING source app softer
```
